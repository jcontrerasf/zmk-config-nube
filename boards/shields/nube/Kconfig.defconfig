## boards/shields/nube/Kconfig.defconfig
```kconfig
if SHIELD_NUBE

config ZMK_KEYBOARD_NAME
    default "nube"

endif # SHIELD_NUBE
```
